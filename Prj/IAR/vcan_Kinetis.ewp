# IAR project vcan_Kinetis.ewp, settings and files
configuration FN15_Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60F15; MK60FN15
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vcan_Kinetis.hex
  ILINK.IlinkOutputFile: vcan_Kinetis.out
configuration FN15_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60F15; MK60FN15
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: vcan_Kinetis.srec
configuration FX15_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60F15; MK60FX15
configuration FX15_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60F15; MK60FX15
  ICCARM.CCOptLevel: 3
configuration DZ10_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB; ..\..\Drivers; ..\..\Drivers\All_Init; ..\..\Drivers\OLED_NEW; ..\..\Drivers\OLED; ..\..\Drivers\lptmr; ..\..\Drivers\IIC_Angle; ..\..\Drivers\ZLG_GUI; ..\..\Drivers\key; ..\..\Drivers\Led; ..\..\Drivers\UI; ..\..\Drivers\Control; ..\..\Drivers\Search; ..\..\Drivers\Fuzzy; ..\..\Drivers\BianMaqi
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Dr_6.bin
  ILINK.IlinkOutputFile: Dr_6.out
  ILINK.IlinkIcfFile: config files\512KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DZ10_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB; ..\..\Drivers\OLED; ..\..\Drivers\All_Init; ..\..\Drivers; ..\..\Drivers\IIC_Angle; ..\..\Drivers\key; ..\..\Drivers\lptmr; ..\..\Drivers\LED; ..\..\Drivers\Flash; ..\..\Drivers\myflash; ..\..\Drivers\Picture; ..\..\Drivers\UI; ..\..\Drivers\Control; ..\..\Drivers\ZLG_GUI; ..\..\Drivers\OLED_NEW
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Car_Dr9.hex
  ILINK.IlinkIcfFile: ..\..\Prj\IAR\config files\vcan_ROM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../../: IO配置备忘录.txt 日志.txt
    ../../App/: main.c MK60_conf.c MK60_it.c
    ../../App/Inc/: MK60_conf.h MK60_it.h PORT_cfg.h
  group Board
    ../../Board/src/: VCAN_ASCII.c VCAN_BMP.c VCAN_camera.c VCAN_computer.c vcan_img2sd.c VCAN_key.c VCAN_key_event.c VCAN_LED.C VCAN_MMA7455.c VCAN_NRF24L0.c VCAN_NRF24L0_MSG.c VCAN_OV7725_Eagle.c VCAN_OV7725_Wolf.c VCAN_RTC_count.C VCAN_SCCB.c vcan_sd_app.c Vcan_touch.c VCAN_TSL1401.c VCAN_UI_VAR.c
  group Chip
    ../../Chip/inc/: common.h
    config files/: DR_6_App.icf
    ../../Chip/src/: misc.c MK60_adc.c MK60_can.c MK60_dac.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_flexbus.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_usb.c MK60_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
  group Drivers/All_Init
    ../../Drivers/All_Init/: All_Init.c All_Init.h
  group Drivers/BianMaqi
    ../../Drivers/BianMaqi/: As5040.c As5040.h
  group Drivers/Control
    ../../Drivers/Control/: Control.c Control.h
  group Drivers/Delay
    ../../Drivers/lptmr/: lptmr.c lptmr.h
  group Drivers/Flash
    ../../Drivers/myflash/: myflash.c myflash.h
  group Drivers/Fuzzy
    ../../Drivers/Fuzzy/: fuzzy.c fuzzy.h
  group Drivers/Key
    ../../Drivers/key/: key.c key.h
  group Drivers/Led
    ../../Drivers/LED/: LED.C LED.H
  group Drivers/MMA8452
    ../../Drivers/IIC_Angle/: IIC.c IIC.h IIIC.c IIIC.H ITG3200.c ITG3200.h MMA8451.c MMA8451.h
  group Drivers/OLED
    ../../Drivers/OLED_NEW/: font.h Oled_New.c Oled_New.h
  group Drivers/Search
    ../../Drivers/Search/: Search.c Search.h Search_1.c Search_1.h Search_2.c Search_2.h
  group Drivers/UI
    ../../Drivers/UI/: UI.c UI.h
  group Drivers/Zlg_GUI
    ../../Drivers/ZLG_GUI/: CONFIG.h ConvertColor.c ConvertColor.H FONT24_32.C FONT24_32.H font5_7.c FONT5_7.H FONT8_8.C FONT8_8.H FONT_MACRO.H GUI_BASIC.C GUI_BASIC.H GUI_CONFIG.H GUI_StockC.C GUI_STOCKC.H lcmdrv.c lcmdrv.h loadbit.c Loadbit.h menu.c menu.h spline.c spline.h windows.c WINDOWS.H
  group LIB/FatFs
    ../../Lib/FatFs/: diskio.c ff.c
  group LIB/USB
    ../../Lib/USB/: USB.c USB_CDC.c
